#pragma once

#include <cstdint>
#include <cstring>
#include <string>
#include <vector>

#ifndef U8X8_PIN_NONE
#define U8X8_PIN_NONE 255
#endif

#ifndef U8G2_R0
#define U8G2_R0 0
#endif

#ifndef U8G2_DRAW_ALL
#define U8G2_DRAW_ALL 0x0F
#endif

inline const uint8_t u8g2_font_6x10_tf[] = {6, 10};
inline const uint8_t u8g2_font_5x7_tf[]  = {5, 7};

class U8G2 {
public:
    virtual ~U8G2() = default;

    void begin() { initialized_ = true; clearBuffer(); }
    void clearBuffer() {
        std::memset(framebuffer_, 0, sizeof(framebuffer_));
        drawnStrings_.clear();
        drawCallCount_ = 0;
    }
    void sendBuffer() { bufferSentCount_++; }

    void setDrawColor(uint8_t color) { drawColor_ = color ? 1 : 0; }
    bool getPixel(int x, int y) const {
        return x >= 0 && x < 128 && y >= 0 && y < 64 && framebuffer_[y][x] != 0;
    }

    void setFont(const uint8_t* font) { currentFontWidth_ = font ? font[0] : 6; }

    int getStrWidth(const char* s) const {
        if (!s) return 0;
        return static_cast<int>(std::strlen(s)) * currentFontWidth_;
    }

    void drawStr(int x, int y, const char* s) {
        if (s) {
            drawnStrings_.emplace_back(s);
            // Rasterize 5x7 bitmap font glyphs into 128x64 framebuffer (baseline at y)
            int cursorX = x;
            const int topY = y - 6;
            for (const char* p = s; *p != '\0'; ++p) {
                const uint8_t* glyph = getGlyph5x7(*p);
                for (int col = 0; col < 5; ++col) {
                    uint8_t bits = glyph[col];
                    for (int row = 0; row < 7; ++row) {
                        if ((bits >> row) & 0x01) {
                            int px = cursorX + col;
                            int py = topY + row;
                            if (px >= 0 && px < 128 && py >= 0 && py < 64) {
                                framebuffer_[py][px] = 1;
                            }
                        }
                    }
                }
                cursorX += currentFontWidth_;
            }
        }
        drawCallCount_++;
    }

    void drawPixel(int x, int y) {
        if (x >= 0 && x < 128 && y >= 0 && y < 64) {
            framebuffer_[y][x] = drawColor_;
        }
        drawCallCount_++;
    }

    void drawHLine(int x, int y, int w) {
        for (int i = 0; i < w; ++i) drawPixel(x + i, y);
    }

    void drawFrame(int x, int y, int w, int h) {
        drawHLine(x, y, w);
        drawHLine(x, y + h - 1, w);
        for (int j = 0; j < h; ++j) {
            drawPixel(x, y + j);
            drawPixel(x + w - 1, y + j);
        }
    }

    void drawBox(int x, int y, int w, int h) {
        for (int j = 0; j < h; ++j) {
            drawHLine(x, y + j, w);
        }
    }

    void drawDisc(int x, int y, int rad, uint8_t opt = U8G2_DRAW_ALL) {
        (void)opt;
        for (int dy = -rad; dy <= rad; ++dy) {
            for (int dx = -rad; dx <= rad; ++dx) {
                if (dx * dx + dy * dy <= rad * rad) {
                    drawPixel(x + dx, y + dy);
                }
            }
        }
    }

    void drawEllipse(int x, int y, int rx, int ry, uint8_t opt = U8G2_DRAW_ALL) {
        (void)opt;
        drawBox(x - rx, y - ry, rx * 2 + 1, ry * 2 + 1);
    }

    bool isInitialized() const { return initialized_; }
    uint32_t getBufferSentCount() const { return bufferSentCount_; }
    uint32_t getDrawCallCount() const { return drawCallCount_; }
    const std::vector<std::string>& getDrawnStrings() const { return drawnStrings_; }
    const uint8_t* getFramebuffer() const { return &framebuffer_[0][0]; }

private:
    uint8_t drawColor_{1};
    static const uint8_t* getGlyph5x7(char c) {
        // Standard 5x7 column-major ASCII font (0x20..0x7E)
        static constexpr uint8_t FONT_5X7[95][5] = {
            {0x00,0x00,0x00,0x00,0x00}, // ' '
            {0x00,0x00,0x5F,0x00,0x00}, // '!'
            {0x00,0x07,0x00,0x07,0x00}, // '"'
            {0x14,0x7F,0x14,0x7F,0x14}, // '#'
            {0x24,0x2A,0x7F,0x2A,0x12}, // '$'
            {0x23,0x13,0x08,0x64,0x62}, // '%'
            {0x36,0x49,0x55,0x22,0x50}, // '&'
            {0x00,0x05,0x03,0x00,0x00}, // '\''
            {0x00,0x1C,0x22,0x41,0x00}, // '('
            {0x00,0x41,0x22,0x1C,0x00}, // ')'
            {0x14,0x08,0x3E,0x08,0x14}, // '*'
            {0x08,0x08,0x3E,0x08,0x08}, // '+'
            {0x00,0x50,0x30,0x00,0x00}, // ','
            {0x08,0x08,0x08,0x08,0x08}, // '-'
            {0x00,0x60,0x60,0x00,0x00}, // '.'
            {0x20,0x10,0x08,0x04,0x02}, // '/'
            {0x3E,0x51,0x49,0x45,0x3E}, // '0'
            {0x00,0x42,0x7F,0x40,0x00}, // '1'
            {0x42,0x61,0x51,0x49,0x46}, // '2'
            {0x21,0x41,0x45,0x4B,0x31}, // '3'
            {0x18,0x14,0x12,0x7F,0x10}, // '4'
            {0x27,0x45,0x45,0x45,0x39}, // '5'
            {0x3C,0x4A,0x49,0x49,0x30}, // '6'
            {0x01,0x71,0x09,0x05,0x03}, // '7'
            {0x36,0x49,0x49,0x49,0x36}, // '8'
            {0x06,0x49,0x49,0x29,0x1E}, // '9'
            {0x00,0x36,0x36,0x00,0x00}, // ':'
            {0x00,0x56,0x36,0x00,0x00}, // ';'
            {0x08,0x14,0x22,0x41,0x00}, // '<'
            {0x14,0x14,0x14,0x14,0x14}, // '='
            {0x00,0x41,0x22,0x14,0x08}, // '>'
            {0x02,0x01,0x51,0x09,0x06}, // '?'
            {0x32,0x49,0x79,0x41,0x3E}, // '@'
            {0x7E,0x11,0x11,0x11,0x7E}, // 'A'
            {0x7F,0x49,0x49,0x49,0x36}, // 'B'
            {0x3E,0x41,0x41,0x41,0x22}, // 'C'
            {0x7F,0x41,0x41,0x22,0x1C}, // 'D'
            {0x7F,0x49,0x49,0x49,0x41}, // 'E'
            {0x7F,0x09,0x09,0x09,0x01}, // 'F'
            {0x3E,0x41,0x49,0x49,0x7A}, // 'G'
            {0x7F,0x08,0x08,0x08,0x7F}, // 'H'
            {0x00,0x41,0x7F,0x41,0x00}, // 'I'
            {0x20,0x40,0x41,0x3F,0x01}, // 'J'
            {0x7F,0x08,0x14,0x22,0x41}, // 'K'
            {0x7F,0x40,0x40,0x40,0x40}, // 'L'
            {0x7F,0x02,0x0C,0x02,0x7F}, // 'M'
            {0x7F,0x04,0x08,0x10,0x7F}, // 'N'
            {0x3E,0x41,0x41,0x41,0x3E}, // 'O'
            {0x7F,0x09,0x09,0x09,0x06}, // 'P'
            {0x3E,0x41,0x51,0x21,0x5E}, // 'Q'
            {0x7F,0x09,0x19,0x29,0x46}, // 'R'
            {0x46,0x49,0x49,0x49,0x31}, // 'S'
            {0x01,0x01,0x7F,0x01,0x01}, // 'T'
            {0x3F,0x40,0x40,0x40,0x3F}, // 'U'
            {0x1F,0x20,0x40,0x20,0x1F}, // 'V'
            {0x3F,0x40,0x38,0x40,0x3F}, // 'W'
            {0x63,0x14,0x08,0x14,0x63}, // 'X'
            {0x07,0x08,0x70,0x08,0x07}, // 'Y'
            {0x61,0x51,0x49,0x45,0x43}, // 'Z'
            {0x00,0x7F,0x41,0x41,0x00}, // '['
            {0x02,0x04,0x08,0x10,0x20}, // '\\'
            {0x00,0x41,0x41,0x7F,0x00}, // ']'
            {0x04,0x02,0x01,0x02,0x04}, // '^'
            {0x40,0x40,0x40,0x40,0x40}, // '_'
            {0x00,0x01,0x02,0x04,0x00}, // '`'
            {0x20,0x54,0x54,0x54,0x78}, // 'a'
            {0x7F,0x48,0x44,0x44,0x38}, // 'b'
            {0x38,0x44,0x44,0x44,0x20}, // 'c'
            {0x38,0x44,0x44,0x48,0x7F}, // 'd'
            {0x38,0x54,0x54,0x54,0x18}, // 'e'
            {0x08,0x7E,0x09,0x01,0x02}, // 'f'
            {0x0C,0x52,0x52,0x52,0x3E}, // 'g'
            {0x7F,0x08,0x04,0x04,0x78}, // 'h'
            {0x00,0x44,0x7D,0x40,0x00}, // 'i'
            {0x20,0x40,0x44,0x3D,0x00}, // 'j'
            {0x7F,0x10,0x28,0x44,0x00}, // 'k'
            {0x00,0x41,0x7F,0x40,0x00}, // 'l'
            {0x7C,0x04,0x18,0x04,0x78}, // 'm'
            {0x7C,0x08,0x04,0x04,0x78}, // 'n'
            {0x38,0x44,0x44,0x44,0x38}, // 'o'
            {0x7C,0x14,0x14,0x14,0x08}, // 'p'
            {0x08,0x14,0x14,0x18,0x7C}, // 'q'
            {0x7C,0x08,0x04,0x04,0x08}, // 'r'
            {0x48,0x54,0x54,0x54,0x20}, // 's'
            {0x04,0x3F,0x44,0x40,0x20}, // 't'
            {0x3C,0x40,0x40,0x20,0x7C}, // 'u'
            {0x1C,0x20,0x40,0x20,0x1C}, // 'v'
            {0x3C,0x40,0x30,0x40,0x3C}, // 'w'
            {0x44,0x28,0x10,0x28,0x44}, // 'x'
            {0x0C,0x50,0x50,0x50,0x3C}, // 'y'
            {0x44,0x64,0x54,0x4C,0x44}, // 'z'
            {0x00,0x08,0x36,0x41,0x00}, // '{'
            {0x00,0x00,0x7F,0x00,0x00}, // '|'
            {0x00,0x41,0x36,0x08,0x00}, // '}'
            {0x08,0x04,0x08,0x10,0x08}  // '~'
        };
        uint8_t idx = (c >= 32 && c <= 126) ? static_cast<uint8_t>(c - 32) : 0;
        return FONT_5X7[idx];
    }

    bool initialized_{false};
    int currentFontWidth_{6};
    uint32_t bufferSentCount_{0};
    uint32_t drawCallCount_{0};
    uint8_t framebuffer_[64][128]{};
    std::vector<std::string> drawnStrings_;
};

class U8G2_SSD1306_128X64_NONAME_F_HW_I2C : public U8G2 {
public:
    U8G2_SSD1306_128X64_NONAME_F_HW_I2C(int rotation, uint8_t reset = U8X8_PIN_NONE) {
        (void)rotation;
        (void)reset;
    }
};
